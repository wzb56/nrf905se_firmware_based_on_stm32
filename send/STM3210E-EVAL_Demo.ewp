# IAR project STM3210E-EVAL_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCIncludePath2: library\inc; board; app
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: STM32_ov7670_Demo.hex
  ILINK.IlinkOutputFile: STM3210E-EVAL_Demo.out
  ILINK.IlinkIcfFile: config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARMv5
    board/: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    library/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_usart.c
  group User
    app/: hw_config.c hw_config.h main.c nrf905.c nrf905.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
